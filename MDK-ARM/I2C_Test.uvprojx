# Keil uVision project I2C_Test.uvprojx, settings and files
target I2C_Test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LE02X FMSH
  pack: FMSH.FM33LE0XX_DFP.1.0.1
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(60000000) ELITTE
  output: I2C_Test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FM33LE0XX,USE_FULL_ASSERT
  c include: ../Drivers/CMSIS/Inculde;../Drivers/FM33LE0xx_FL_Driver/Inc;../Drivers/CMSIS/Device/FM/FM33xx/Include;../MF-config/Inc;../Inc;..\ArduinoAPI;..\Core
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33le0xx.s
  group Application/MF-config
    ../MF-config/Src/: mf_config.c
  group Application/User
    ../Src/: main.cpp I2C.c I2CTest.c
    ../Inc/: I2C.h I2CTest.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/FM/FM33xx/Source/: system_fm33le0xx.c
  group Drivers/FM33LE0xx_FL_Driver
    ../Drivers/FM33LE0xx_FL_Driver/Src/: fm33le0xx_fl_adc.c fm33le0xx_fl_aes.c fm33le0xx_fl_atim.c fm33le0xx_fl_bstim32.c fm33le0xx_fl_comp.c fm33le0xx_fl_crc.c fm33le0xx_fl_dma.c fm33le0xx_fl_flash.c fm33le0xx_fl_gpio.c fm33le0xx_fl_gptim.c fm33le0xx_fl_divas.c fm33le0xx_fl_i2c.c fm33le0xx_fl_i2csmb.c fm33le0xx_fl_iwdt.c fm33le0xx_fl_lptim32.c fm33le0xx_fl_lpuart.c fm33le0xx_fl_opa.c fm33le0xx_fl_pmu.c fm33le0xx_fl_rcc.c fm33le0xx_fl_rng.c fm33le0xx_fl_rtc.c fm33le0xx_fl_spi.c fm33le0xx_fl_svd.c fm33le0xx_fl_u7816.c fm33le0xx_fl_uart.c fm33le0xx_fl_wwdt.c fm33le0xx_fl_lcd.c fm33le0xx_fl_exti.c fm33le0xx_fl.c
  group Arduino API
    ../ArduinoAPI/: Arduino.c Wire.cpp WireBase.cpp
  group Core
    ../Core/: delay.c gpio.c
